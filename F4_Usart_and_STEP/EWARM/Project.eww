<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\F4_Usart_and_STEP.ewp</path>
  </project>
  <batchBuild />
</workspace>
